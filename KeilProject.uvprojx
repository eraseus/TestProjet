# Keil uVision project KeilProject.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: KeilProject
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group Source Group 1
    ./: Source1.c
